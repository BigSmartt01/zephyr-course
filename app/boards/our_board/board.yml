## app/boards/our_board/board.yml
```yaml
board:
  name: our_board
  full_name: OUR BOARD
  vendor: iomico
  socs:
  - name: esp32c3
```
